PACKAGECONFIG += "faad2 fluidsynth libcdio libmms openal sqlite3"
