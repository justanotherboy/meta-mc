FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://snd_usb.cfg"
